FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://mpu-6050.cfg"

